# Keil uVision project project_h456.uvprojx, settings and files
target H456 Combined (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project_h456
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __MSPM0G3507__,H456_COMBINED_BUILD=1,BALL_BALANCE_ALLOW_SEQUENCE=0,CHASSIS_TELEMETRY_CAPACITY=1
  c include: ..\user;..\code;..\ml_libs;..\m0_sdk\source;..\m0_sdk\source\third_party\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: ../m0_sdk/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group user
    ./: main.c flash_padding.c startup_mspm0g350x_uvision.s isr.c
    ../m0_sdk/source/ti/devices/msp/m0p/: mspm0g350x.h
  group code
    ../code/: pid.c pid.h motor_velocity.c motor_velocity.h line_sensor.c line_sensor.h chassis_track_line_control.c chassis_track_line_control.h chassis_config.c chassis_config.h chassis_odometry.c chassis_odometry.h chassis_heading_fusion.c chassis_heading_fusion.h chassis_motion.c chassis_motion.h chassis.c chassis.h chassis_telemetry.c chassis_telemetry.h chassis_telemetry_uart.c chassis_telemetry_uart.h chassis_key.c chassis_key.h imu_attitude.c imu_attitude.h icm42688_service.c icm42688_service.h h456_app.c h456_app.h h456_mission.c h456_mission.h h456_telemetry.c h456_telemetry.h ball_balance.c ball_balance.h ball_balance_config.h rds3230.c rds3230.h maix_ball_protocol.c maix_ball_protocol.h
  group ml_libs
    ../ml_libs/: ml_common.h ml_board.c ml_board.h headfile.h ml_gpio.c ml_gpio.h ml_tim.c ml_tim.h ml_uart.c ml_uart.h ml_delay.c ml_delay.h ml_system.c ml_system.h ml_pwm.c ml_pwm.h ml_oled.c ml_oled.h ml_oled_font.h ml_i2c.c ml_i2c.h icm42688.c icm42688.h FusionAhrs.c FusionAhrs.h FusionMath.h FusionConvention.h ml_exti.c ml_exti.h ml_motor_driver.c ml_motor_driver.h ml_quadrature.c ml_quadrature.h ml_encoder.c ml_encoder.h ml_motor.c ml_motor.h
